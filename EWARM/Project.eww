<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_F407ZGT6(FreeRTOS+HAL).ewp</path>
  </project>
  <batchBuild />
</workspace>
